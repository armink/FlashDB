# IAR project FlashDB.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; STM32F103xE
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\User\app; ..\..\SEGGER\RTT\RTT; ..\..\SEGGER\HARDFAULTHANDLER\HardFaultHandlerIAR; ..\..\..\..\port\fal\inc; ..\..\..\..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashDB.hex
  ILINK.IlinkOutputFile: stm32-f3.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../../User/app/: main.c stm32f10x_assert.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h
  group BSP/Driver
    ../../User/bsp/src/: bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group EWARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group FlashDB
    ../../../../src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group FlashDB/FAL
    ../../../../port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../../../../port/fal/samples/porting/: fal_flash_stm32f1_port.c
  group SAMPLES
    ../../../../samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
  group SEGGER/RTT
    ../../SEGGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
