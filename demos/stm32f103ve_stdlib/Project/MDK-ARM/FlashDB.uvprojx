# Keil uVision project FlashDB.uvprojx, settings and files
target Flash (6150000::V6.15::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F103xE
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\SEGGER\RTT\RTT;..\..\User\app;..\..\..\..\inc;..\..\..\..\port\fal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../../User/app/: main.c stm32f10x_assert.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group SAMPLES
    ../../../../samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h
    ../../User/bsp/src/: bsp_timer.c bsp_uart_fifo.c
  group SEGGER/RTT
    ../../SEGGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group FlashDB
    ../../../../src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group FAL
    ../../../../port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../../../../port/fal/samples/porting/: fal_flash_stm32f1_port.c
  group STDPERIPH_DRIVER
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c system_stm32f10x.h
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.4.0
